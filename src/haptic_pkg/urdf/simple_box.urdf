Commit message: updated

File: src/haptic_pkg/urdf/simple_box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link box: geometry collision box size=0.38 0.4 0.15; visual box size=0.38 0.4 0.15
